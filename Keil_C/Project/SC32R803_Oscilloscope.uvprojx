# Keil uVision project SC32R803_Oscilloscope.uvprojx, settings and files
target SC32R803_Oscilloscope (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: SC32R803TR8 SinOneMicroelectronics
  pack: SinOne.SC32F1xxx_DFP_V1.1.1.5
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: SC32R803_Oscilloscope +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: SC32R803
  c include: ..\FWLib\SC32F1XXX_Lib\inc;..\User\HeadFiles;..\Drivers;..\Apps;..\CMSIS;..\User
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group User
    ../User/: SC_it.c CompCtrlDefine.c CallBackFunction.c SysFunVarDefine.c SC_Init.c main.c system_sc32f1xxx.c SC_it.h Wave_Show_gy.c Wave_Show_gy.h Data_Acquisition.c Data_Acquisition.h FFT_XTC.c FFT_XTC.h Menu.c Menu.h Global_Variables.c
  group Apps
    ../Apps/: Picture.c TFT_Lcd.c lcdfont.c
  group Drivers
    ../Drivers/TKDriverNew/C/: SC_M0+_HighSensitive_lib_T2_V1.0.lib TKDriver.c SC_M0+_HighSensitive_lib_Slider_V1.0.lib SC_M0+_HighSensitive_lib_Basic_V1.0.lib TKDriver.h
  group FWLib
    ../FWLib/SC32F1XXX_Lib/src/: sc32f1xxx_tim.c sc32f1xxx_adc.c sc32f1xxx_spi.c sc32f1xxx_uart.c sc32f1xxx_rcc.c sc32f1xxx_option.c sc32f1xxx_gpio.c sc32f1xxx_dma.c sc32f1xxx_btm.c sc32f1xxx_can.c sc32f1xxx_cmp.c sc32f1xxx_crc.c sc32f1xxx_dac.c sc32f1xxx_iap.c sc32f1xxx_int.c sc32f1xxx_lcd.c sc32f1xxx_led.c sc32f1xxx_ledpwm.c sc32f1xxx_op.c sc32f1xxx_pga.c sc32f1xxx_pwm.c sc32f1xxx_pwr.c sc32f1xxx_qep.c sc32f1xxx_qspi.c sc32f1xxx_spi1_twi1.c sc32f1xxx_temper.c sc32f1xxx_twi.c sc32f1xxx_vref.c sc32f1xxx_wdt.c
    ../FWLib/SC32F1XXX_Lib/inc/: sc32f1xxx_uart.h
  group Startup
    ./: startup_sc32r803.s
